# Keil uVision project Application.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Application
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group main
    ./: main.c
  group startup_file
    ./: startup_LPC17xx.s
  group lib_SoC_board
    ./: system_LPC17xx.c core_cm3.c
  group include
    ./: core_cm3.h LPC17xx.h system_LPC17xx.h
  group LED
    ./LED/: LED.c LED.h
  group GLCD
    ./GLCD/: Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c
  group IRQ
    ./: IRQ.c
  group Pictures
    ./: BTN_START.c LOGO.c BACKGROUND.c CAR1.c EMPTYCAR.c BGBARS.c GAMEOVER.c ITEMS.c
  group CAN
    ./CAN/: CAN.c CAN.h
software components: CMSIS:CORE 5.5.0
